<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SPI_Simple\SPI_Simple.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SPI_Slave\SPI_Slave.ewp</path>
  </project>
  <batchBuild/>
</workspace>


