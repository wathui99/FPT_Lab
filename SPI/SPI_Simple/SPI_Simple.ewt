<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>Lib</name>
    <file>
      <name>$PROJ_DIR$\src\clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\itc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\lcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\tim4.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\src\main.c</name>
    </file>
  </group>
</project>


