# IAR project test_stack.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: test; stm8l-periphs; stm8l; kernel
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: test_stack.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group kernel
    kernel/: atomkernel.c atommutex.c atomqueue.c atomsem.c atomtimer.c
  group periphs
    stm8l-periphs/: clk.c gpio.c tim1.c
  group stm8l
    stm8l/: atomport-asm-iar.s atomport.c tests-main.c uart.c
  group test
    test/: test_stack.c
