# IAR project 2_stack_2_tcb.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: ATOM_STACK_CHECKING
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; stm8l-periphs; kernel
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: 2_stack_2_tcb.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group kernel
    kernel/: atomkernel.c atommutex.c atomqueue.c atomsem.c atomtimer.c
  group stm8l-periphs
    stm8l-periphs/: clk.c gpio.c tim1.c tim4.c
  group stm8l-port
    ./: atomport-asm-iar.s atomport.c tests-main.c uart.c
