<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\test_2_stack_2_tcb\2_stack_2_tcb.ewp</path>
    </project>
    <batchBuild />
</workspace>
