# IAR project port_atom_v2.1.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: kernel; $PROJ_DIR$; stm8l-periphs; test
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: port_atom_v2.1.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group kernel
    kernel/: atomkernel.c atommutex.c atomqueue.c atomsem.c atomtimer.c
  group periphs
    stm8l-periphs/: clk.c gpio.c tim1.c
    ./: uart.c
  group stm8
    ./: atomport-asm-iar.s atomport.c tests-main.c
