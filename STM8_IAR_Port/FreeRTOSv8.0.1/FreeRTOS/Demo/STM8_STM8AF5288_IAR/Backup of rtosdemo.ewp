# IAR project Backup of rtosdemo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8AF51AA STM8AF51AA
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x64
  General.GenHeapSize: 0x10
  ICCSTM8.CCDefines: STM8S208; IAR_STM8S; USE_STM8_128_EVAL
  ICCSTM8.CCIncludePath2: ..\..\Source\include; ..\Common\include; $PROJ_DIR$; STM8S_StdPeriph_Driver\inc; \..\..\..\..\Demo\STM8_STM8AF5288_IAR\STM8S_StdPeriph_Driver\inc; $TOOLKIT_DIR$\INC; $TOOLKIT_DIR$\INC\C
  ICCSTM8.IccLang: 0
  ASTM8.AsmIncludePath: $PROJ_DIR$; STM8S_StdPeriph_Driver\inc; \..\..\..\..\Demo\STM8_STM8AF5288_IAR\STM8S_StdPeriph_Driver\inc; $TOOLKIT_DIR$\INC\C
  OBJCOPY.OOCOutputFile: rtosdemo.srec
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group Demo Source
    ../Common/Minimal/: comtest.c crflash.c integer.c PollQ.c
    ../../Source/portable/MemMang/: heap_1.c
    ./: main.c regtest.c
    ParTest/: ParTest.c
    serial/: serial.c
  group Kernel Source
    ../../Source/: croutine.c list.c queue.c tasks.c
    ../../Source/portable/IAR/STM8AF5288/: port.c portmacro.s
  group STM8S_StdPeriph_Driver
    STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_adc2.c stm8s_awu.c stm8s_beep.c stm8s_can.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_tim5.c stm8s_tim6.c stm8s_uart1.c stm8s_uart2.c stm8s_uart3.c stm8s_wwdg.c
