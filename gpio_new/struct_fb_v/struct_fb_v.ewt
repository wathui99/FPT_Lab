<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>Library</name>
    <file>
      <name>$PROJ_DIR$\Library\src\clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Library\src\tim4.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
  </group>
  <file>
    <name>$PROJ_DIR$\User\main.c</name>
  </file>
</project>


