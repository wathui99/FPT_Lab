# IAR project TIMING.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: E:\download\Thuc\project\stm8l\TIM1\TIMING\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: TIMING.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Lib
    src/: clk.c lcd.c tim1.c
  group User
    src/: main.c
