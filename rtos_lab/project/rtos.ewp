# IAR project rtos.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: ATOM_STACK_CHECKING
  ICCSTM8.CCDiagSuppress: Pa050
  ICCSTM8.CCIncludePath2: ..\ports\stm8\stm8l-periphs; ..\inc; ..\kernel; ..\ports; ..\ports\stm8; ..\tests
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: rtos.srec
  ILINK.IlinkOutputFile: rtos.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group kernel
    ../kernel/: atomkernel.c atommutex.c atomqueue.c atomsem.c atomtimer.c
  group port
    ../ports/stm8/: atomport-asm-iar.s atomport.c
  group stm8l-periphs
    ../ports/stm8/stm8l-periphs/: stm8l152c6_clk.c stm8l152c6_clock.c stm8l_gpio.c stm8l_lcd.c stm8l_timer1.c
  group user
    ../user/: main.c
