<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Transmit\V01\Transmit_V01.ewp</path>
    </project>
    <batchBuild />
</workspace>
