# IAR project Transmit_V01.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151K6 STM8L151K6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: Transmit_V01.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Lib
    src/: clk.c exti.c gpio.c itc.c nRF24.c spi.c tim4.c usart.c
  group User
    src/: main.c
