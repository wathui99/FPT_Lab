<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\external interrupt\external_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\tim4\tim4.ewp</path>
  </project>
  <batchBuild/>
</workspace>


